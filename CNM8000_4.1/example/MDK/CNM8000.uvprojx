# Keil uVision project CNM8000.uvprojx, settings and files
target CNM8000 (6140000::V6.14::ARMCLANG)
  device: HC32L130J8UA HDSC
  pack: HDSC.HC32L13x.1.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CNM8000 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\mcu\common;..\source;..\..\driver\inc;..\CN121
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../mcu/common/: interrupts_hc32l13x.c system_hc32l13x.c
  group source
    ../source/: main.c
  group driver
    ../../driver/src/: ddl.c sysctrl.c adc.c gpio.c bgr.c uart.c dmac.c timer3.c bt.c flash.c
  group README
    ../: readme.txt
  group CN121
    ../CN121/: CN121_utils.c CN121_qrs_Det.c CN121_HR_smooth.c CN121_ECG_Filter.c CN121_API.c
software components: CMSIS:CORE 6.0.0
